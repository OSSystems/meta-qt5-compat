FILES_${PN}-dev += "${datadir}/cmake"
